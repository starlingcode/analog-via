File: analog-via.kicad_pcb (KiCad board)
At the start: 4 copper layers, 213.5 x 128.5 mm, 753 parts, among them IC1 SSI2164, IC2 SSI2164, J1 2164_CV, J10 TRIGGER, J11 SLEW_CV, J12 Conn_02x04_Odd_Even, J13 Conn_01x04, J14 INB, J15 COMP_CTL_A, J16 LOW_COMP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

Commit message: update servo integrator to provide additional configuration options and add missing decoupling caps
Parts:
- added C48: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (123.1, 117.1)
- added C49: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (132.7, 117.2)
- added C56: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (37.8, 98.8)
- added C57: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (48.2, 116.4)
- added C63: DNP, Capacitor_SMD:C_0805_2012Metric, F.Cu at (138.0, 116.2)
- added C64: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (106.8, 121.7)
- added D1: 1N5819, Diode_SMD:D_SOD-123, F.Cu at (109.0, 126.1)
- added D2: 1N5819, Diode_SMD:D_SOD-123, F.Cu at (106.6, 126.1)
- added J75: TRANSIMPEDANCE_AMP_OUT, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, F.Cu at (148.3, 121.6)
- added R72: 10k, Resistor_SMD:R_0805_2012Metric, F.Cu at (109.0, 121.7)
- added R73: 10k, Resistor_SMD:R_0805_2012Metric, F.Cu at (117.1, 126.2)
- added R74: 0R, Resistor_SMD:R_0805_2012Metric, F.Cu at (121.4, 122.9)
- added R88: 1M, Resistor_SMD:R_0805_2012Metric, F.Cu at (142.0, 131.7)
- added R89: 1M, Resistor_SMD:R_0805_2012Metric, F.Cu at (145.1, 121.5)
- moved J72 4.40 mm to (51.7, 117.7)
- moved C51 4.18 mm to (121.4, 127.0), turned to 0 degrees
- moved U30 0.53 mm to (37.8, 101.4)
Connections:
- C51 pad 1: Net-(U35A--) -> Net-(C51-Pad1)
- U35 pad 6: INTEGRATOR_II_OUT -> Net-(U35B--)
Routing:
- net Net-(U33A--): track 2.42 -> 26.7 mm
- net Net-(J75-Pin_1): track 3.14 -> 18.1 mm
- net Net-(U35B--): track 0.00 -> 12.8 mm
- net Net-(D1-K): track 79.1 -> 86.6 mm
- net GND: track 206.8 -> 213.9 mm, vias 107 -> 114
- net Net-(U35A--): track 93.0 -> 97.8 mm
- net HOLD_REF: track 134.2 -> 138.6 mm
- net +5V: track 44.9 -> 48.9 mm
- net Net-(C51-Pad1): track 0.00 -> 3.58 mm
- net +12V: track 134.8 -> 137.2 mm, vias 53 -> 52
- net Net-(U32-Ch): track 17.2 -> 19.1 mm
- net MOVEMENT_TRIG: track 13.1 -> 14.9 mm
- net -12V: track 63.9 -> 65.4 mm
- net GATE_MODE: track 54.5 -> 55.9 mm
- net INTEGRATOR_II_OUT: track 29.6 -> 30.8 mm
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Other:
- board text added: "MVMT TRIG"
- board text added: "TIA OUT"
- board text removed: "MOVEMENT TRIG"
