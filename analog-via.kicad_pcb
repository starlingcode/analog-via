# Repository starlingcode/analog-via

File README.md:

# analog-via
Designs for an all-analog variant of the VIA meta crossfader/envelope generator/oscillator

## KiCad design analog-via.kicad_pcb

Schematic: analog-via.kicad_sch

Parts:
C1, C5, C7, C9, C11, C13, C15, C18, C19, C21, C22, C23, C24, C27, C28, C30, C31, C32, C33, C34, C35, C37, C38, C39, C40, C41, C44, C45, C46, C48, C49, C54, C56, C57, C58, C59, C60, C61, C62, C64: 100n; C_0805_2012Metric
C2, C4, C6, C10, C12, C17, C20, C52: 1200p; C_0805_2012Metric
C3, C8, C16, C47: 100p; C_0805_2012Metric
C25, C26: 10uF; C_0805_2012Metric
C42, C43: 22u; C_0805_2012Metric
C50, C51: 1.2n; C_0805_2012Metric
C53: 1uF; C_0805_2012Metric
C55: 100nF; C_0805_2012Metric
C63: DNP; C_0805_2012Metric
D1, D2: 1N5819; D_SOD-123
D3: 1N5819; D_SOD-123; JLCPCB C8598
D4: 1n4148; D_SOD-123
D5, D6, D7, D8: LED; LED_0805_2012Metric
IC1, IC2: SSI2164; SOIC-16_3.9x9.9mm_P1.27mm
J1: 2164_CV; PinHeader_1x02_P2.54mm_Vertical
J2: 5VREF; PinHeader_1x01_P2.54mm_Vertical
J3: EXPO_IN; PinHeader_1x01_P2.54mm_Vertical
J4: FF_DIRECTION; PinHeader_1x01_P2.54mm_Vertical
J5: SLOPE; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J6: EOC; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J7: OUTPUT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J8: HOLD_REF; PinHeader_1x01_P2.54mm_Vertical
J9: DIRECTION; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J10: TRIGGER; PinHeader_1x01_P2.54mm_Vertical
J11: SLEW_CV; PinHeader_1x01_P2.54mm_Vertical
J12, J32: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J13, J30, J31: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J14: INB; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J15: COMP_CTL_A; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
J16: LOW_COMP; PinHeader_1x01_P2.00mm_Vertical
J17: HIGH_COMP; PinHeader_1x01_P2.00mm_Vertical
J18, J39: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J19: OUTPUT; PinHeader_1x01_P2.00mm_Vertical
J20: COMP_CTL_B; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
J21: INV_SLOPE; PinHeader_1x01_P2.54mm_Vertical
J22: SLOPE; PinHeader_1x01_P2.54mm_Vertical
J23: POWER; PinHeader_2x05_P2.54mm_Vertical
J24: TRIGGER; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J25: SYNC; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J26: RISE; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J27: FALL; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J28: INA; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J29, J34, J35, J43, J46, J47, J55, J56, J57, J58, J59, J61: GND; PinHeader_1x01_P2.54mm_Vertical
J33: BOUNDS; PinHeader_1x01_P2.00mm_Vertical
J36: FALL_SUM; PinHeader_1x01_P2.54mm_Vertical
J37: RISE_SUM; PinHeader_1x01_P2.54mm_Vertical
J38: Conn_02x02_Counter_Clockwise; PinHeader_2x02_P2.54mm_Vertical
J40: SLOPE_FREQ_MOD; PinHeader_1x01_P2.54mm_Vertical
J41: INA; PinHeader_1x01_P2.54mm_Vertical
J42: INB; PinHeader_1x01_P2.54mm_Vertical
J44: ~{SYNC}; PinHeader_1x01_P2.54mm_Vertical
J45: SPARE_OUT; PinHeader_1x01_P2.54mm_Vertical
J48, J52: +12V; PinHeader_1x01_P2.54mm_Vertical
J49, J53: -12V; PinHeader_1x01_P2.54mm_Vertical
J50: 1V/OCT; PinHeader_1x01_P2.54mm_Vertical
J51, J54: +5V; PinHeader_1x01_P2.54mm_Vertical
J60: SPARE_IN; PinHeader_1x02_P2.54mm_Vertical
J62: INTEGRATOR_BUFFER; PinHeader_1x01_P2.54mm_Vertical
J63: BIT1; PinHeader_1x01_P2.54mm_Vertical
J64: HOLD_REF_INV; PinHeader_1x01_P2.54mm_Vertical
J65: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J66: BIT0; PinHeader_1x01_P2.54mm_Vertical
J67: ENABLE_DECAY; PinHeader_1x01_P2.54mm_Vertical
J68: AT_TARGET; PinHeader_1x01_P2.00mm_Vertical
J69: EOA; PinHeader_1x01_P2.54mm_Vertical
J70: DECAY_TRIG; PinHeader_1x01_P2.54mm_Vertical
J71: DIR_CHANGE; PinHeader_1x01_P2.54mm_Vertical
J72: MOVEMENT_TRIG; PinHeader_1x01_P2.54mm_Vertical
J73: FILTERED_TRIG; PinHeader_1x01_P2.54mm_Vertical
J74: FILTER_CRITERIA; PinHeader_1x01_P2.54mm_Vertical
J75: TRANSIMPEDANCE_AMP_OUT; PinHeader_1x01_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R1, R92: 845; R_0805_2012Metric
R2: 1K; R_0805_2012Metric
R3, R4, R18, R34, R42, R46, R51, R57, R58, R59, R61, R62, R63, R64, R76, R77, R78, R79, R80, R84, R94, R102, R104, R107, R110: 100k; R_0805_2012Metric
R5, R8, R10, R98, R99, R100, R101: 1k; R_0805_2012Metric
R6: 340; R_0805_2012Metric
R7: 100; R_0805_2012Metric
R9, R31, R32, R37, R39, R53, R56, R91: 220; R_0805_2012Metric
R19, R93: 150k; R_0805_2012Metric
R20, R21: 100k 1%; R_0805_2012Metric
R24: 1.69M; R_0805_2012Metric
R25: 200; R_0805_2012Metric
R26: 47k; R_0805_2012Metric
R30, R35, R47, R49, R71, R90: 33k; R_0805_2012Metric
R33: 500K; R_0805_2012Metric
R36, R43, R44, R72, R73, R83, R103: 10k; R_0805_2012Metric
R38, R54, R87, R106: 4.7k; R_0805_2012Metric
R40, R41: DNP; R_0805_2012Metric
R52, R55: 50k; R_0805_2012Metric
R69: 10M; R_0805_2012Metric; JLC C7250
R74: 0R; R_0805_2012Metric
R82, R85: 200k; R_0805_2012Metric
R86, R88, R89, R105, R108: 1M; R_0805_2012Metric
R95, R96: 300k; R_0805_2012Metric
R97: 600k; R_0805_2012Metric
R109: 1; R_0805_2012Metric
RV1: 10k; Potentiometer_Bourns_TC33X_Vertical; JLCPCB C911365
RV2, RV3: 10k; Potentiometer_TT_P0915N
RV4: 100k; Potentiometer_TT_P0915N
U1: 74HC74; SOIC-14_3.9x8.7mm_P1.27mm; JLCPCB C27597
U2: LM4040DBZ-5; SOT-23; JLCPCB C460604
U3, U6, U16, U19: TMUX4053; TSSOP-16_4.4x5mm_P0.65mm
U4, U7, U11, U14: OPA1678; SOIC-8_3.9x4.9mm_P1.27mm; JLCPCB C192421
U8: LM3900; SOIC-14_3.9x8.7mm_P1.27mm
U9: OPA1679; SOIC-14_3.9x8.7mm_P1.27mm; JLCPCB C2878631
U10: 74LS08; SOIC-14_3.9x8.7mm_P1.27mm
U12, U13: LM311; SOIC-8_3.9x4.9mm_P1.27mm; JLCPCB C12597
U17: LM319; SOIC-14_3.9x8.7mm_P1.27mm
U18: AMS1117-5.0; SOT-223-3_TabPin2; JLCPCB C6187
U22: 74AHC1G32; SOT-23-5; JLC C10096
U30: 74AHC1G86; SOT-353_SC-70-5; JLC C460494
U32: LF398_SOIC14; SOIC-14_3.9x8.7mm_P1.27mm
U33, U35: OPA1678; SOIC-8_3.9x4.9mm_P1.27mm
U37: TL431DBZ; SOT-23
U39, U40: 74HC14; SOIC-14_3.9x8.7mm_P1.27mm
U42: 74HC237; SOIC-16_4.55x10.3mm_P1.27mm; JLC C2674497

Connections:
1V/OCT: J50.1, R3.1
5VREF: C53.1, J2.1, R20.1, R92.2, RV2.3, RV3.3, U2.1 (K), U13.3 (-), U16.1, U16.13
+5V: C13.1, C24.1, C27.1, C43.1, C55.1, C56.1, C57.1, C60.1, C61.1, J13.1, J13.2, J13.3, J13.4, J51.1, J54.1, R36.1, R84.2, R87.1, R96.2, R97.2, R104.2, R106.1, R109.2, RV4.3, U1.13 (~R), U1.14 (VCC), U8.14 (VCC), U10.14 (VCC), U22.5 (VCC), U30.5 (VCC), U39.14 (VCC), U40.14 (VCC), U42.6 (E2), U42.16 (VCC)
+12V: C5.1, C9.1, C11.1, C15.1, C18.1, C21.1, C23.1, C25.1, C28.1, C30.1, C33.1, C40.2, C41.2, C42.1, C45.1, C49.1, C54.1, C58.1, IC1.16 (V+), IC2.16 (V+), J23.9, J23.10, J48.1, J52.1, R1.2, R92.1, U3.16 (VDD), U4.8 (V+), U7.8 (V+), U9.4 (V+), U11.8 (V+), U12.8 (V+), U13.8 (V+), U14.8 (V+), U16.16 (VDD), U17.11 (V+), U18.3 (VI), U19.16 (VDD), U32.12 (V+), U33.8 (V+), U35.8 (V+)
-5V: R21.2, R33.2, R42.2, R43.2, R52.2, R58.2, RV2.1, RV3.1, U4.1, U16.2, U16.12
-12V: C7.2, C19.1, C22.1, C26.2, C31.2, C32.2, C34.2, C35.2, C37.2, C38.2, C39.2, C44.2, C46.2, C48.1, C59.2, C62.2, IC1.9 (V-), IC2.9 (V-), J23.1, J23.2, J49.1, J53.1, U4.4 (V-), U7.4 (V-), U9.11 (V-), U11.4 (V-), U12.4 (V-), U13.4 (V-), U14.4 (V-), U16.7 (VEE), U17.6 (V-), U19.7 (VEE), U32.3 (V-), U33.4 (V-), U35.4 (V-)
ACTIVATION_TRIG: U1.1 (~R), U6.4
AT_TARGET: J65.2, J68.1, U1.5 (Q), U6.11, U10.2, U10.10, U12.6 (STRB), U13.6 (STRB)
BIT0: J66.1, U8.4, U42.1 (A0)
BIT1: J63.1, R95.2, U8.5, U42.2 (A1)
DECAY_TRIG: J70.1, U10.6, U22.2
DIRECTION: R10.1, U3.4, U10.1, U16.9, U16.11, U19.9, U39.5
DIR_CHANGE: J71.1, U1.11 (C), U6.5, U22.4
ENABLE_DECAY: J67.1, U10.4
ENV_MODE: J12.3, R80.1, U3.11
EOA: J69.1, U10.3, U10.5
EOC: R5.1, U3.12, U10.8
FALL_CV: J27.T, R61.1
FF_DIRECTION: J4.1, U1.9 (Q), U3.5
FILTERED_TRIG: J73.1, U3.2, U10.11
FILTER_CRITERIA: J74.1, U3.14, U10.13
FULL_CYCLE_MODE: J12.1
GATE: J18.1, U30.1
GATE_EDGE_TRIG: U6.3, U30.4
GATE_MODE: J12.7, R79.1, U3.9, U6.9
GND: C1.2, C2.1, C4.1, C5.2, C6.2, C7.1, C9.2, C10.1, C11.2, C12.1, C13.2, C15.2, C17.1, C18.2, C19.2, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, C27.2, C28.2, C30.2, C31.1, C32.1, C33.2, C34.1, C35.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.2, C43.2, C44.1, C45.2, C46.1, C48.2, C49.2, C50.1, C52.1, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.1, C60.2, C61.2, C62.1, D1.2 (A), D2.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), IC1.8 (GND), IC2.8 (GND), J5.S, J6.S, J7.S, J9.S, J14.S, J23.3, J23.4, J23.5, J23.6, J23.7, J23.8, J24.S, J24.TN, J25.S, J26.S, J27.S, J28.S, J29.1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
HOLD_REF: J8.1, R30.1, U16.14, U32.1 (I), U35.5 (+)
HOLD_REF_INV: J64.1, R71.1, U16.15
INA: J28.T, J41.1, R35.1
INB: J14.T, J42.1, R49.1
INTEGRATOR_II_OUT: C51.2, J38.3, R73.2, U35.1
INV_DIRECTION: U3.13, U10.9, U16.10, U39.6
INV_SLOPE: J21.1, R46.1, R55.2, R57.1, U11.1
MODE0: J12.2, R98.2, U42.12 (Y3)
MODE1: J12.4, R99.2, U42.13 (Y2)
MODE2: J12.6, R100.2, U42.14 (Y1)
MODE3: J12.8, R101.2, U42.15 (Y0)
MODE_CV: R18.1, R94.1
MOVEMENT_TRIG: J72.1, U3.15, U22.1
unnamed: C2.2, R9.1
unnamed: C4.2, R31.1
unnamed: C6.1, R32.2
unnamed: C8.2, R38.2, U9.8
unnamed: C10.2, R37.1
unnamed: C12.2, R39.1
unnamed: C16.2, R54.2, U9.14
unnamed: C17.2, R53.1
unnamed: C20.2, R56.1
unnamed: C47.2, U40.4
unnamed: C51.1, R74.2
unnamed: C52.2, R91.1
unnamed: C64.2, D1.1 (K), D2.2 (A), R72.2, U6.13, U35.7
unnamed: C47.1, D3.2 (A), R102.2
unnamed: D3.1 (K), R110.2, U40.1
unnamed: D4.2 (A), R95.1
unnamed: D4.1 (K), R97.1, U8.3 (-)
unnamed: D5.2 (A), R98.1
unnamed: D6.2 (A), R99.1
unnamed: D7.2 (A), R100.1
unnamed: D8.2 (A), R101.1
unnamed: IC1.2 (IN), R30.2, R31.2
unnamed: C63.1, IC1.4 (OUT), R90.2, U33.6 (-)
unnamed: IC1.7 (IN), R32.1, R33.1
unnamed: IC1.5 (OUT), R24.2, R25.1
unnamed: IC1.11 (CTRL), R6.2, R7.1
unnamed: IC1.10 (IN), J1.2, R9.2
unnamed: C3.1, IC1.12 (OUT), J3.1, R24.1, R26.1, U7.6 (-)
unnamed: IC1.15 (IN), R71.2, R91.2
unnamed: IC1.13 (OUT), R69.1, U6.12
unnamed: IC2.3 (CTRL), J15.2
unnamed: IC2.2 (IN), R39.2, R42.1
unnamed: C8.1, IC2.4 (OUT), R34.2, U9.9 (-)
unnamed: IC2.6 (CTRL), J15.1, R38.1
unnamed: IC2.7 (IN), R35.2, R37.2
unnamed: IC2.5 (OUT), IC2.13 (OUT), R47.1, U9.2 (-)
unnamed: IC2.11 (CTRL), J20.2
unnamed: IC2.10 (IN), R56.2, R58.1
unnamed: C16.1, IC2.12 (OUT), R46.2, U9.13 (-)
unnamed: IC2.14 (CTRL), J20.1, R54.1
unnamed: IC2.15 (IN), R49.2, R53.2
unnamed: J1.1, R3.2, R4.2
unnamed: J5.T, R2.2
unnamed: J6.T, R5.2
unnamed: J7.T, R8.2
unnamed: J9.T, R10.2
unnamed: J16.1, R40.1, U12.7, U19.5
unnamed: J17.1, R41.1, U13.7, U19.3
unnamed: J18.2, U39.1
unnamed: J30.1, U19.15
unnamed: J30.2, U19.10
unnamed: J30.3, U19.1
unnamed: J30.4, U19.2
unnamed: J31.1, U40.6
unnamed: J31.2, U40.8
unnamed: J31.3, U40.10
unnamed: J31.4, U40.12
unnamed: J32.2, U40.5
unnamed: J32.4, U40.9
unnamed: J32.6, U40.11
unnamed: J32.8, U40.13
unnamed: J36.1, R61.2, R63.1, R76.2, U14.2 (-)
unnamed: J37.1, R62.2, R64.1, R77.2, U14.6 (-)
unnamed: J38.1, J38.2, R44.1, R51.1, U12.3 (-)
unnamed: J39.1, U39.12
unnamed: J39.2, U30.2
unnamed: J45.1, U39.8
unnamed: J60.1, U39.9
unnamed: J62.1, R82.2, R85.2, U33.1
unnamed: J65.1, U32.11 (Hold)
unnamed: C63.2, J75.1, R89.2, R90.1, U33.7
unnamed: JP1.2 (B), U4.5 (+)
unnamed: JP2.1 (A), U4.7
unnamed: JP2.2 (B), U4.6 (-)
unnamed: JP3.2 (B), U9.5 (+)
unnamed: JP4.1 (A), U9.7
unnamed: JP4.2 (B), U9.6 (-)
unnamed: JP5.2 (B), U7.3 (+)
unnamed: JP6.1 (A), U7.1
unnamed: JP6.2 (B), U7.2 (-)
unnamed: R19.1, R93.1, RV4.2
unnamed: R26.2, RV1.1
unnamed: R63.2, U14.1, U16.5
unnamed: R64.2, U14.7, U16.3
unnamed: R76.1, RV2.2
unnamed: R77.1, RV3.2
unnamed: R86.2, R87.2, U17.12, U40.3
unnamed: U1.8 (~Q), U1.12 (D)
unnamed: R20.2, R21.1, U4.2 (-)
unnamed: R18.2, R19.2, U8.1 (+)
unnamed: R96.1, U8.6 (-)
unnamed: R93.2, R94.2, U8.2 (+)
unnamed: R51.2, R52.1, R55.1, U11.2 (-)
unnamed: R57.2, R59.1, U11.6 (-)
unnamed: R40.2, R43.1, U12.2 (+)
unnamed: R41.2, R44.2, U13.2 (+)
unnamed: R83.2, R84.1, R86.1, U17.4 (+)
unnamed: R105.1, R107.2, U17.9 (+)
unnamed: R103.2, R104.1, U17.10 (-)
unnamed: R109.1, U18.2 (VO)
unnamed: C50.2, R82.1, R88.1, U32.8 (Ch), U33.3 (+)
unnamed: R85.1, R89.1, U33.2 (-)
unnamed: R74.1, U6.14, U35.2 (-)
unnamed: C64.1, R72.1, R73.1, U35.6 (-)
unnamed: C1.1, R1.1, R6.1, U37.1 (K), U37.2 (REF)
unnamed: U39.2, U39.3
unnamed: U39.10, U39.13
unnamed: U39.4, U39.11
OUTPUT: J19.1, R8.1, R47.2, U9.1
PENDULUM_MODE: J12.5, R78.1, U3.10
RISE_CV: J26.T, R62.1
S+H_INTEGRATOR_OUT: J38.4, U32.7
SLEW_CV: C3.2, IC1.3 (CTRL), IC1.6 (CTRL), IC1.14 (CTRL), J11.1, RV1.2, RV1.3, U7.7
SLOPE: J22.1, R2.1, R34.1, R59.2, U11.7
SLOPE_FREQ_MOD: J40.1, R4.1, U16.4
SYNC_IN: J25.T, U17.5 (-)
TRIGGER: J10.1, R105.2, R106.2, U3.1, U3.3, U10.12, U17.7
TRIGGER_IN: J24.T, R107.1, R108.1
~BOUNDS: J33.1, R36.2, U1.4 (~S), U19.4
~SYNC: J44.1, U1.10 (~S), U40.2

Notes on the sheet:
rise/fall cv
EXPO CONVERTER/SLEW CV GENERATOR
FILTER_CRITERIA is a mode-dependent mechanism for choosing relevant triggers Either EOC or INV_DIRECTION
CALCULATE HYSTERESIS/INPUT RESISTANCE
crossfader
exponential converter temperature compensated
FULL_CYCLE_MODE does nothing
Clamping diodes: keeps integrator close to GND when open-loop. Could be schottkys?
trig/sync
slope
POWER
ENABLE DECAY is a mode switch DECAY_TRIG will cause a slope down immediately from 5V
NEED ENABLE_DECAY
SYNC
Can this be +5V?
REFERENCE VOLTAGES
ALL MODES OFF IS "FULL CYLCLE MODE"
EXTRA INVERTERS
flip flop mode logic
HIGH = RISING
servo integrator
CALCULATE RESISTANCES FOR FEEDBACK NETWORK
AND mode logic
https://tinyurl.com/26u8mvxu
BOUNDS DETECTION AND SLOPE BUFFERING
bounds active low
reference
Consider reducing impedance to 7.5k
MOVEMENT_TRIG is the product of the switch network e.g. in pendulum mode, every external trig is a MOVEMENT_TRIG for the two "trigger modes", MOVEMENT_TRIG is the external trig filtered by the slope generator's state.
s+h integrator
MAKE SURE THIS IS SET UP TO BE AT A when slope is -5 and B when slope is 5
HOLD IN
HOLD-> AT_TARGET OR !SYNC?
CROSSFADER
reference/bounds
20nS MINIMUM
SERVO INTEGRATOR
https://tinyurl.com/24ptj5km
tantalum
BUFFER SOMEWHERE HERE?

Board: 4 copper layers, 213.5 x 128.5 mm, 269 parts (0 on the bottom side), 158 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C14, C15, C18, C19, C21, C22, C23, C24, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C44, C45, C5, C7, C9",0805,28,100n,
"C10, C12, C17, C2, C20, C4, C6",0805,7,1200p,
C13,0805,1,1.2n,
"C16, C27, C28, C3, C8",0805,5,100p,
"C25, C26",0805,2,10uF,
"C42, C43",0805,2,22u,
D1,D_SOD-123,1,1N5819,
D2,D_SOD-123,1,D_Schottky,
"IC1, IC2",SOIC-16_3.9x9.9mm_P1.27mm,2,SSI2164,
J1,PinHeader_1x02_P2.54mm_Vertical,1,2164_CV,
J10,PinHeader_1x01_P2.54mm_Vertical,1,2164_IN,
J11,PinHeader_1x01_P2.54mm_Vertical,1,SLEW_CV,
J12,PinHeader_1x01_P2.54mm_Vertical,1,2164_CTL,
J13,PinHeader_1x01_P2.54mm_Vertical,1,2164_OUT,
J14,PinHeader_1x01_P2.54mm_Vertical,1,INTEGRATOR_IN,
J15,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,1,COMP_CTL_A,
J16,PinHeader_1x01_P2.00mm_Vertical,1,HIGH_COMP,
J17,PinHeader_1x01_P2.00mm_Vertical,1,LOW_COMP,
J18,PinHeader_1x02_P2.54mm_Vertical,1,INTEGRATOR,
J19,PinHeader_1x01_P2.00mm_Vertical,1,OUTPUT,
J2,PinHeader_1x01_P2.54mm_Vertical,1,5VREF,
J20,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,1,COMP_CTL_B,
J21,PinHeader_1x01_P2.54mm_Vertical,1,INV_SLOPE,
J22,PinHeader_1x01_P2.54mm_Vertical,1,SLOPE,
J23,PinHeader_2x05_P2.54mm_Vertical,1,POWER,
J24,PinHeader_1x01_P2.54mm_Vertical,1,SYNC,
J25,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,TRIGGER,
J26,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,SYNC,
J27,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,RISE,
J28,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,FALL,
J29,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,INA,
J3,PinHeader_1x01_P2.54mm_Vertical,1,EXPO_IN,
J30,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,INB,
J31,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,OUTPUT,
J32,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,DIRECTION,
J33,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,EOC,
J34,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,SLOPE,
J35,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,CLK/2,
J36,PinHeader_1x01_P2.54mm_Vertical,1,FALL_SUM,
J37,PinHeader_1x01_P2.54mm_Vertical,1,RISE_SUM,
J39,PinHeader_1x01_P2.54mm_Vertical,1,2.5VREF,
J4,PinHeader_1x01_P2.54mm_Vertical,1,FF_TRIGGER,
J40,PinHeader_1x01_P2.54mm_Vertical,1,SLOPE_FREQ_MOD,
J41,PinHeader_1x01_P2.54mm_Vertical,1,INA,
J42,PinHeader_1x01_P2.54mm_Vertical,1,INB,
J43,PinHeader_1x06_P2.54mm_Vertical,1,Conn_01x06,
J44,PinHeader_1x01_P2.54mm_Vertical,1,EXTRA_SW_B,
J45,PinHeader_1x01_P2.54mm_Vertical,1,EXTRA_SW_C,
J46,PinHeader_1x01_P2.54mm_Vertical,1,LOGIC_S1,
J47,PinHeader_1x01_P2.54mm_Vertical,1,LOGIC_S2,
J48,PinHeader_1x01_P2.54mm_Vertical,1,LOGIC_S3,
J49,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03,
J5,PinHeader_1x01_P2.54mm_Vertical,1,ONESHOT_OR_RETRIG,
J50,PinHeader_1x01_P2.54mm_Vertical,1,1V/OCT,
J6,PinHeader_1x01_P2.54mm_Vertical,1,TRIGGER,
J7,PinHeader_1x01_P2.54mm_Vertical,1,EOC,
J8,PinHeader_1x01_P2.54mm_Vertical,1,HOLD_REF,
J9,Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,1,INPUT,
"JP1, JP2, JP3, JP4, JP5, JP6",PinHeader_1x02_P2.54mm_Vertical,6,Jumper_2_Open,
Q1,SOT-23,1,MMBFJ112,
Q2,SOT-23-3,1,PNP,
R1,0805,1,840,
"R10, R40, R41, R5",0805,4,1M,
"R11, R12, R13, R14, R15, R16, R3, R34, R4, R42, R46, R51, R57, R58, R59, R61, R62, R63, R64, R66, R67, R68, R69, R71, R76, R77, R78, R79, R80",0805,29,100k,
"R17, R2, R22, R23, R36, R43, R44, R45, R48, R65, R70, R8",0805,12,10k,
"R18, R19, R20, R21",0805,4,100k 1%,
R24,0805,1,1.69M,
R25,0805,1,200,
R26,0805,1,47.5k,
"R27, R28, R29, R30, R35, R47, R49",0805,7,33k,
"R31, R32, R37, R39, R53, R56, R9",0805,7,220,
R33,0805,1,500K,
"R38, R54",0805,2,4.7k,
"R50, R60, R72, R73, R74, R75",0805,6,1k,
"R52, R55",0805,2,50k,
R6,0805,1,339,
R7,0805,1,100,
RV1,Potentiometer_Bourns_TC33X_Vertical,1,10k,
"RV2, RV3",Potentiometer_TT_P0915N,2,10k,
U1,SOIC-14_3.9x8.7mm_P1.27mm,1,74HC74,
"U11, U14, U15, U4, U7",SOIC-8_3.9x4.9mm_P1.27mm,5,OPA1678,
"U12, U13",SOIC-8_3.9x4.9mm_P1.27mm,2,LM311,
"U16, U19, U3",TSSOP-16_4.4x5mm_P0.65mm,3,TMUX4053PWR,
U18,SOT-223-3_TabPin2,1,AMS1117-5.0,
U2,SOT-23,1,LM4040DBZ-5,
U5,SOIC-14_3.9x8.7mm_P1.27mm,1,LM339,
U9,SOIC-14_3.9x8.7mm_P1.27mm,1,OPA1679,

## Commit log

2024-11-18 Added license
2025-01-03 V1 prototype production 12-15-24
2025-01-03 cleaned up repository ignores
2025-01-04 rotated op amp packages and corrected power supply issues, ratsnest still needs corrections
2025-01-04 removed stale backups
2025-05-18 pre-re-annotation, completed next rev schematic capture
2025-05-18 routing
2025-05-19 v2 routed, no drc yet
2025-05-25 v2 proto passes DRC
2025-05-25 update servo integrator to provide additional configuration options and add missing decoupling caps
2025-08-13 update schematic with Will's debugging notes

Notices in the files:
analog-via.kicad_pcb:
CC BY-SA-NC 2025
